options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bb_rate
  id: variable
  parameters:
    value: psk31_baud*samples_per_symbol
  states: {}
- name: c
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.1'
  states: {state: disabled}
- name: if_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: lp
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: if_rate/2
    gain: int(samp_rate/if_rate)
    samp_rate: samp_rate
    width: if_rate/tr_factor
    win: firdes.WIN_HAMMING
  states: {}
- name: lp_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bb_rate/2
    gain: int(if_rate/bb_rate)
    samp_rate: if_rate
    width: bb_rate/tr_factor
    win: firdes.WIN_HAMMING
  states: {}
- name: psk31_baud
  id: variable
  parameters:
    value: '31.25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '16'
  states: {}
- name: test
  id: variable
  parameters:
    value: len(lp)
  states: {}
- name: test_0
  id: variable
  parameters:
    value: len(lp_0)
  states: {}
- name: tr_factor
  id: variable
  parameters:
    value: '5'
  states: {}
- name: bbg
  id: parameter
  parameters:
    label: baseband gain
    type: intx
    value: '0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1234'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: |-
      (0,0, 1,1,0,1,1,0,1, 0,0, 1,0,1,0,1,1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,1,1,1,1,1, 0,0, 1,0,1,0,1,0,1,1,0,1, 0,0, 1,1,1,0,1,1,0,1, 0,0,
      1,1,1,0,1,1,1, 0,0, 1,1,1,0,1,1,1, 0,0, 1,1,1,0,1,1,1,0,1, 0,0, 1, 0,0, 1,0,1, 0,0, 1,1, 0,0, 1,0,1,1,1, 0,0, 1,0,1, 0,0, 1,1,0,1, 0,0, 1,1,1,1, 0,0, 1,0,1,1,0,1,1, 0,0, 1,0,1,0,1,1,1, 0,0, 1,1,1,0,1)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: c
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: samples_per_symbol
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Complex Logger',   # will show up in GRC
                  in_sig= [np.complex64],
                  out_sig= None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              print(input_items[0])
              return len(input_items[0])
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: freq
    short_id: f
    type: eng_float
    value: '2400000000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '0.5'
  states: {}
- name: ifg
  id: parameter
  parameters:
    label: IF gain
    type: intx
    value: '20'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(samp_rate/if_rate)
    taps: lp
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(if_rate/bb_rate)
    taps: lp_0
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: bbg
    freq0: freq
    gain0: rfg
    if_gain0: ifg
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: '0'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: psk31_encoder
  id: epy_block
  parameters:
    _source_code: "\n\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='PSK31 Encoder',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        self.eol = True\n        self.psk31 = {\n            '1010101011' : '\\x00',    '1011011011' : '\\x01',\n            '1011101101' : '\\x02',    '1101110111' : '\\x03',\n            '1011101011' : '\\x04',    '1101011111' : '\\x05',\n            '1011101111' : '\\x06',    '1011111101' : '\\x07',\n            '1011111111' : '\\x08',    '11101111'   : '\\x09',\n            '11101'      : '\\x0A',    '1101101111' : '\\x0B',\n            '1011011101' : '\\x0C',    '11111'      : '\\x0D',\n            '1101110101' : '\\x0E',    '1110101011' : '\\x0F',\n            '1011110111' : '\\x10',    '1011110101' : '\\x11',\n            '1110101101' : '\\x12',    '1110101111' : '\\x13',\n            '1101011011' : '\\x14',    '1101101011' : '\\x15',\n            '1101101101' : '\\x16',    '1101010111' : '\\x17',\n            '1101111011' : '\\x18',    '1101111101' : '\\x19',\n            '1110110111' : '\\x1A',    '1101010101' : '\\x1B',\n            '1101011101' : '\\x1C',    '1110111011' : '\\x1D',\n            '1011111011' : '\\x1E',    '1101111111' : '\\x1F',\n            '1'          : ' ',       '111111111'  : '!',\n            '101011111'  : '\"',       '111110101'  : '#',\n            '111011011'  : '$',       '1011010101' : '%',\n            '1010111011' : '&',       '101111111'  : '\\'',\n            '11111011'   : '(',       '11110111'   : ')',\n            '101101111'  : '*',       '111011111'  : '+',\n            '1110101'    : ',',       '110101'     : '-',\n            '1010111'    : '.',       '110101111'  : '/',\n            '10110111'   : '0',       '10111101'   : '1',\n            '11101101'   : '2',       '11111111'   : '3',\n            '101110111'  : '4',       '101011011'  : '5',\n            '101101011'  : '6',       '110101101'  : '7',\n            '110101011'  : '8',       '110110111'  : '9',\n            '11110101'   : ':',       '110111101'  : ';',\n            '111101101'  : '<',       '1010101'    : '=',\n            '111010111'  : '>',       '1010101111' : '?',\n            '1010111101' : '@',       '1111101'    : 'A',\n            '11101011'   : 'B',       '10101101'   : 'C',\n            '10110101'   : 'D',       '1110111'    : 'E',\n            '11011011'   : 'F',       '11111101'   : 'G',\n            '101010101'  : 'H',       '1111111'    : 'I',\n            '111111101'  : 'J',       '101111101'  : 'K',\n            '11010111'   : 'L',       '10111011'   : 'M',\n            '11011101'   : 'N',       '10101011'   : 'O',\n            '11010101'   : 'P',       '111011101'  : 'Q',\n            '10101111'   : 'R',       '1101111'    : 'S',\n            '1101101'    : 'T',       '101010111'  : 'U',\n            '110110101'  : 'V',       '101011101'  : 'W',\n            '101110101'  : 'X',       '101111011'  : 'Y',\n            '1010101101' : 'Z',       '111110111'  : '[',\n            '111101111'  : '\\\\',      '111111011'  : ']',\n            '1010111111' : '^',       '101101101'  : '_',\n            '1011011111' : '`',       '1011'       : 'a',\n            '1011111'    : 'b',       '101111'     : 'c',\n            '101101'     : 'd',       '11'         : 'e',\n            '111101'     : 'f',       '1011011'    : 'g',\n            '101011'     : 'h',       '1101'       : 'i',\n            '111101011'  : 'j',       '10111111'   : 'k',\n            '11011'      : 'l',       '111011'     : 'm',\n            '1111'       : 'n',       '111'        : 'o',\n            '111111'     : 'p',       '110111111'  : 'q',\n            '10101'      : 'r',       '10111'      : 's',\n            '101'        : 't',       '110111'     : 'u',\n            '1111011'    : 'v',       '1101011'    : 'w',\n            '11011111'   : 'x',       '1011101'    : 'y',\n            '111010101'  : 'z',       '1010110111' : '{',\n            '110111011'  : '|',       '1010110101' : '}',\n            '1011010111' : '~',       '1110110101' : '\\x7F' \n        }\n\n    def general_work(self, input_items, output_items):\n        #print \"requested output items:\", len(output_items[0])\n        #print \"passed input items\", len(input_items[0])\n        if len(input_items[0]) == 0:\n            #print \"no input items\"\n            return 0\n        output = self.translate_text([input_items[0][0]])\n        #print \"produced items:\", len(output)\n        if len(output) > len(output_items[0]):\n            #print \"too few output items requested\"\n            return 0\n        output_items[0][:len(output)] = [ x for x in output ]\n        self.consume_each(1)\n        return len(output)\n\n    def forecast(self, ninput_items_required, noutput_items):\n        #print noutput_items\n        ninput_items_required = int(noutput_items / 14)\n        return ninput_items_required\n\n    def translate_text(self,bytearray):\n        translation = []\n        for byte in bytearray:\n            char = chr(byte & 255)\n            keys = [key  for (key, value) in self.psk31.items() if value == char]\n            if keys:\n                if self.eol:\n                    #key = pmt.intern(\"\")\n                    #value = pmt.intern(\"tx_sob\")\n                    #self.add_item_tag(0, self.nitems_written(0), key, value)\n                    self.eol = False\n                    #translation.extend([0] * 64)                \n                translation.extend((0,0))\n                translation.extend(map(int,list(keys[0])))\n            if (char == '\\n'):\n                translation.extend([0] * 128)\n                #key = pmt.intern(\"\")\n                #value = pmt.intern(\"tx_eob\")\n                #self.add_item_tag(0, self.nitems_written(0)+128, key, value)   \n                self.eol = True                \n            print(char,keys,translation)\n        return translation\n        "
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rfg
  id: parameter
  parameters:
    label: RF Gain
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_udp_source_0, '0', psk31_encoder, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_2, '0', digital_map_bb_0, '0']
- [digital_constellation_modulator_0, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_null_sink_0, '0']
- [psk31_encoder, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
