options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bb_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: lp
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bb_rate/2
    gain: int(samp_rate/bb_rate)
    samp_rate: samp_rate
    width: bb_rate/10
    win: firdes.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: bbg
  id: parameter
  parameters:
    label: baseband gain
    type: intx
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1.2 * bb_rate / wpm)
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1234'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0,0,0,0,0, 1,1,1,0,1,0,1, 0,0,0, 1, 0,0,0,0,0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1,0,1,1,1,0,1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0,0,0,0,0, 1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1, 0,0,0, 1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,1,1,0,1, 0,0,0, 1,1,1,0,1,1,1,0,1, 0,0,0,0,0,0,0)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Morse Encoder',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.complex64]\n        )\n        self.eol = True\n        # International morse code (sample)\n        self.morse = {\n            # Letters\n            \"a\": \".-\",\n            \"b\": \"-...\",\n            \"c\": \"-.-.\",\n            \"d\": \"-..\",\n            \"e\": \".\",\n            \"f\": \"..-.\",\n            \"g\": \"--.\",\n            \"h\": \"....\",\n            \"i\": \"..\",\n            \"j\": \".---\",\n            \"k\": \"-.-\",\n            \"l\": \".-..\",\n            \"m\": \"--\",\n            \"n\": \"-.\",\n            \"o\": \"---\",\n            \"p\": \".--.\",\n            \"q\": \"--.-\",\n            \"r\": \".-.\",\n            \"s\": \"...\",\n            \"t\": \"-\",\n            \"u\": \"..-\",\n            \"v\": \"...-\",\n            \"w\": \".--\",\n            \"x\": \"-..-\",\n            \"y\": \"-.--\",\n            \"z\": \"--..\",\n            # Numbers\n            \"0\": \"-----\",\n            \"1\": \".----\",\n            \"2\": \"..---\",\n            \"3\": \"...--\",\n            \"4\": \"....-\",\n            \"5\": \".....\",\n            \"6\": \"-....\",\n            \"7\": \"--...\",\n            \"8\": \"---..\",\n            \"9\": \"----.\",\n            # Punctuation\n            \"&\": \".-...\",\n            \"'\": \".----.\",\n            \"@\": \".--.-.\",\n            \")\": \"-.--.-\",\n            \"(\": \"-.--.\",\n            \":\": \"---...\",\n            \",\": \"--..--\",\n            \"=\": \"-...-\",\n            \"!\": \"-.-.--\",\n            \".\": \".-.-.-\",\n            \"-\": \"-....-\",\n            \"+\": \".-.-.\",\n            '\"': \".-..-.\",\n            \"?\": \"..--..\",\n            \"/\": \"-..-.\",\n        }\n\n    def general_work(self, input_items, output_items):\n        #print \"requested output items:\", len(output_items[0])\n        #print \"passed input items\", len(input_items[0])\n        if len(input_items[0]) == 0:\n            #print \"no input items\"\n            return 0\n        output = self.translate_text([input_items[0][0]])\n        #print \"produced items:\", len(output)\n        if len(output) > len(output_items[0]):\n            #print \"too few output items requested\"\n            return 0\n        output_items[0][:len(output)] = [ x for x in output ]\n        self.consume_each(1)\n        return len(output)\n\n    def forecast(self, ninput_items_required, noutput_items):\n        #print noutput_items\n        ninput_items_required = int(noutput_items / 14)\n        return ninput_items_required\n\n    def translate_text(self,bytearray):\n        translation = []\n        for byte in bytearray:\n            char = chr(byte)\n            if char.lower() in self.morse:\n                morsecode = self.morse[char.lower()]\n                if self.eol:\n                    self.eol = False\n                    translation.extend([0,0,0])\n                for dihdah in morsecode:\n                    if dihdah == '.':\n                        translation.extend([1,0])\n                    else:\n                        translation.extend([1,1,1,0])\n                translation.extend([0,0])\n            elif (char == ' '):\n                morsecode = 'space'\n                translation.extend([0,0,0,0])\n            elif (char == '\\n'):\n                morsecode = 'eol'\n                translation.extend([0,0,0,0])\n                self.eol = True\n            else:\n                morsecode = 'n/a'\n            print(char,morsecode,translation)\n        return translation\n        "
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import sys
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Complex Logger',   # will show up in GRC
                  in_sig= [np.complex64],
                  out_sig= None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              print(input_items[0])
              return len(input_items[0])
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: freq
    short_id: f
    type: eng_float
    value: '2400000000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '.15'
  states: {}
- name: ifg
  id: parameter
  parameters:
    label: IF gain
    type: intx
    value: '20'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(samp_rate/bb_rate)
    taps: lp
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: bbg
    freq0: freq
    gain0: rfg
    if_gain0: ifg
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: '0'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rfg
  id: parameter
  parameters:
    label: RF Gain
    type: intx
    value: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: rrc_taps
    samp_rate: bb_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: '1'
    ntaps: rrc_taps
    samp_rate: bb_rate
    sym_rate: '5'
    type: interp_fir_filter_ccf
  states: {}
- name: wpm
  id: parameter
  parameters:
    label: wpm
    short_id: w
    type: intx
    value: '20'
  states: {}

connections:
- [blocks_repeat_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_udp_source_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']
- [interp_fir_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_null_sink_0, '0']
- [root_raised_cosine_filter_0, '0', interp_fir_filter_xxx_0, '0']
- [root_raised_cosine_filter_1, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
